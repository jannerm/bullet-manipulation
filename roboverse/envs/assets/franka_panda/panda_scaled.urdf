Commit message: franka changed reward + fixed urdf

File: roboverse/envs/assets/franka_panda/panda_scaled.urdf (robot description, URDF)
Before this commit: robot panda, 13 links, 12 joints
Joints:
- joint panda_finger_joint2: axis 0 -1 0 -> 0 1 0
