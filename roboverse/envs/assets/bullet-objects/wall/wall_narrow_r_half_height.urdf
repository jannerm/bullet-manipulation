Commit message: v6 new_env_setting=1

File: roboverse/envs/assets/bullet-objects/wall/wall_narrow_r_half_height.urdf (robot description, URDF)
Before this commit: robot bowl.urdf, 2 links, 1 joints
Links:
- link base: geometry collision box size=.01 1 .1; collision box size=1 .01 .1
