Commit message: Make Widow250 grasp v6 functional. Pretty reliable grasp success rate for beer bottle.

File: roboverse/envs/assets/interbotix_descriptions/urdf/wx250.urdf (robot description, URDF)
Before this commit: robot wx250, 13 links, 12 joints
Links:
- link /base_link: mass 0.538736 -> 0.0
