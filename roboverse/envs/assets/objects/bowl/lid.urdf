Commit message: WIP

File: roboverse/envs/assets/objects/bowl/lid.urdf (robot description, URDF)
Before this commit: robot bowl.urdf, 2 links, 1 joints
Links:
- link lid: geometry collision box size=1.05 1.05 .1; visual box size=1.05 1.05 .2
